# Keil uVision project main.uvproj, settings and files
target Target 1 (MCS-51)
  device: CH543 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0xFF)  IROM(0-0x3FFF) CLOCK(48000000)
  output: main +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 CH9445F.c DEBUG.C main.c PD_PHY.c PD_PROT.c Timer.C
